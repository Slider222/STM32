# Keil uVision project STM_Project.uvprojx, settings and files
target Scaner (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM_Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\MyInclude
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group mainGroup
    ./: main.c
  group myInclude
    ./MyInclude/: funct.c delay.c AnMotors.c
software components: CMSIS:CORE 5.0.2, Device:Startup 1.0.0
